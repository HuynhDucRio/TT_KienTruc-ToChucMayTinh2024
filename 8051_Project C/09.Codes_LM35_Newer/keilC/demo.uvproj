# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\libraries
  group Source Group 1
    ./: main.c
    ../../libraries/: LCD2004.c delay.c adc0808.c
