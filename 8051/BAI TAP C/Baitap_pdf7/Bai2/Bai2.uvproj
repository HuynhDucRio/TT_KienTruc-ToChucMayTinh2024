# Keil uVision project Bai2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Bai2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\8051_Project C\libraries
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../../../8051_Project C/libraries/: delay.c
